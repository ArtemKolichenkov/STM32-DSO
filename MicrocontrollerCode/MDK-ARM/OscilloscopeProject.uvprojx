# Keil uVision project OscilloscopeProject.uvprojx, settings and files
target OscilloscopeProject (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: OscilloscopeProject
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --C99
  c include: ../Inc;                                                   ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                   ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                   ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                                                   ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;                                                   ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                   ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_core.c usbd_ctlreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/User
    ../Src/: usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c usbd_desc.c usb_device.c main.c usbd_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_adc.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
software components: CMSIS:CORE 4.1.0
